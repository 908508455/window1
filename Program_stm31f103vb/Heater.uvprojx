# Keil uVision project Heater.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Heater +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\CORE;.\STM32F10x_FWLib\inc;.\USER;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\HARDWARE\LED;.\HARDWARE\KEY;.\HARDWARE\IIC;.\HARDWARE\24CXX;.\HARDWARE\SPI;.\HARDWARE\BEEP;.\HARDWARE\LCD;.\HARDWARE\DMA;.\HARDWARE\USART;.\QRENCODE;.\funlib;.\HARDWARE\ADC;.\HARDWARE\TIMER;.\HARDWARE\EXTI;.\HARDWARE\SIM900A;.\HARDWARE\RTC;..\Program;.\QRENCODE;.\STemWinLibrary522\inc;.\STemWinLibrary522\Config;.\STemWinLibrary522\Demo;.\HARDWARE\DLED;.\HARDWARE\MFRC522;.\HARDWARE\EXTI;.\HARDWARE\STMFLASH
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ./CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_flash1.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
  group HARDWARE
    ./HARDWARE/LED/: led.c
    ./HARDWARE/BEEP/: beep.c
    ./HARDWARE/KEY/: key.c
    ./HARDWARE/DMA/: dma.c
    ./HARDWARE/TIMER/: timer.c
    ./HARDWARE/USART/: usart2.c usart3.c
    ./HARDWARE/DLED/: dled.c
    ./HARDWARE/EXTI/: exti.c
    ./HARDWARE/STMFLASH/: stmflash.c
software components: CMSIS:CORE 4.3.0
